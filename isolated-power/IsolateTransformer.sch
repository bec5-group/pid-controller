File: isolated-power/IsolateTransformer.sch (KiCad schematic (older format))
At the start: 80 parts

Commit message: [isolated-power] annotation
Parts:
- gave numbers to parts that had none: 80
